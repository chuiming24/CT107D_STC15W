# Keil uVision project 2016.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2016 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP(逻辑模块);..\CORE（内核模块）;..\HARDWARE（硬件模块）
  group HEARDWARE
    ../HARDWARE（硬件模块）/: display.c key.c onewire.c
  group APP
    ../APP(逻辑模块)/: word_gui.c set_gui.c
  group CORE
    ../CORE（内核模块）/: stc_config.h
  group MAIN
    ./: main.c
